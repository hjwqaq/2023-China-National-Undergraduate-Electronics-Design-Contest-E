# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\STEER;..\HARDWARE\ENCODER;..\HARDWARE\KEY;..\HARDWARE\MOTOR;..\HARDWARE\USART2;..\CONTROL\CONTROL;..\CONTROL\MOTORPWM;..\MPU6050\IIC;..\MPU6050\MPU6050;..\MPU6050\MPU6050\eMPL;..\HARDWARE\EXTIX;..\HARDWARE\XUNJI;..\HARDWARE\USART3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CONTROL
    ../CONTROL/CONTROL/: control.c
    ../CONTROL/MOTORPWM/: motorpwm.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/STEER/: steer.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/EXTIX/: extix.c
    ../HARDWARE/XUNJI/: xunji.c
    ../HARDWARE/USART3/: usart3.c
  group MPU6050
    ../MPU6050/MPU6050/: mpu6050.c
    ../MPU6050/IIC/: myiic.c
    ../MPU6050/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_pwr.c
  group README
    ../: readme.txt
